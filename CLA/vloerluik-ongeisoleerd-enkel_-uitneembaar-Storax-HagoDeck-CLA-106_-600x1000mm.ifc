Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 9e3dd15a-d8ee-4141-8a2e-110d43c3e261.ifc
Time: 2026-09-11T10:47:37
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck CLA 106, 600x1000mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAB_Fp9EDAAAAWloBAAV2SgAA2FMBAFJfAQDxgwAAN1kBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAB_Fp9EDAAAAWloBAAV2SgAA2FMBAFJfAQDxgwAAN1kBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 15 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 720 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 1120 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: A15; type: CLA 106; dagmaatbreedte: 1000 mm; omranding: aluminium; luik: aluminium
