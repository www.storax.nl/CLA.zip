Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 117fda51-9dd1-4dd2-a5cc-aa5f76b576ca.ifc
Time: 2026-09-11T10:29:05
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck CLA 44, 400x400mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAB8mp9EDAAAAWloBAAV2SgAA2FMBAFJfAQDxgwAA1FkBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAB8mp9EDAAAAWloBAAV2SgAA2FMBAFJfAQDxgwAA1FkBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 7 kg/st; STABU2: 43.31.10; dagmaatlengte: 400 mm; lengte: 520 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 520 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: A15; type: CLA 44; dagmaatbreedte: 400 mm; omranding: aluminium; luik: aluminium
