Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: c8961846-585e-4935-9bf1-9126354c57f2.ifc
Time: 2026-09-11T10:47:16
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck CLA 88, 800x800mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAB86ptEDAAAAWloBAAV2SgAA2FMBAFJfAQDxgwAAyFgBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAB86ptEDAAAAWloBAAV2SgAA2FMBAFJfAQDxgwAAyFgBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 15 kg/st; STABU2: 43.31.10; dagmaatlengte: 800 mm; lengte: 920 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 920 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: A15; type: CLA 88; dagmaatbreedte: 800 mm; omranding: aluminium; luik: aluminium
